#
# Copyright (C) 2015 Wind River Systems, Inc.
#

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-kexec-ppc64-use-only-the-crashing-cpu-to-boot-the-cr.patch"
