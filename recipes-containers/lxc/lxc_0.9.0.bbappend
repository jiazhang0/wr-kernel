# Fix configure.ac:82: error: possibly undefined macro: AC_MSG_ERROR
inherit pkgconfig
